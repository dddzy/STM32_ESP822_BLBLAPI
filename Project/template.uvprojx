# Keil uVision project template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Driver\delay;..\Driver\sys;..\Driver\usart;..\Driver\STM32f10x_FWLib\libraries\inc;..\Driver\STM32f10x_FWLib;..\Driver\LED;..\Driver
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Stm32F10x_CruxFile
    ../Driver/STM32f10x_FWLib/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group Stm32F10x_FWLib
    ../Driver/STM32f10x_FWLib/libraries/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c misc.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_spi.c
    ../Driver/STM32f10x_FWLib/: startup_stm32f10x_md.s
  group Driver
    ../Driver/delay/: delay.c
    ../Driver/sys/: sys.c
    ../Driver/usart/: usart.c
    ../Driver/LED/: led.c
    ../Driver/oled/: OLED_I2C.c
    ../Driver/wifi/: wifi.c
    ../Driver/systemtime/: systemtime.c
    ../Driver/tim/: tim.c
    ../Driver/USART3/: usart3.c
    ../Driver/pc/: pc.c
    ../Driver/W25QXX/: w25qxx.c spi.c
    ../Driver/KEY/: key.c
  group User
    ../User/: main.c
  group Readme
    ../Readme/: Readme.txt
